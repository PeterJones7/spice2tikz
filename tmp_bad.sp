bad deck
V1 a 0 5
R1 a 0 1k
.end
